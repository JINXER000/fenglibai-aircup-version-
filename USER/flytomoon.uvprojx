# Keil uVision project flytomoon.uvprojx, settings and files
target MPU6050 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: MPU6050 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\IIC;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\FWLIB\inc;..\HARDWARE\KEY;..\USMART;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c BSP_NVIC.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/MPU6050/: mpu6050.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/: fan.c ospid.c pwm.c timer.c Kalman_filter.c indkey.c UART2.c mympu6050.c iic_analog.c
    ./: JY61.c niming.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group README
    ../: readme.txt
